# Keil uVision project Project.uvprojx, settings and files
target STM32L073RZ_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073RZ_NUCLEO
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L073xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_dma.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal.c stm32l0xx_hal_rcc.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart.c stm32l0xx_hal_gpio.c stm32l0xx_hal_spi.c
  group Application/User
    ../Src/: stm32l0xx_it.c stm32l0xx_hal_msp.c main.c lcd.c ugui.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/Headers
    ../Inc/: lcd.h ugui.h
software components: CMSIS:CORE 4.3.0
